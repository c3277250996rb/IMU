# Keil uVision project stm32l151rct6.uvprojx, settings and files
target stm32l151rct6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L151RC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: stm32l151rct6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32L151xC
  c include: ../Core/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Core/Code/Main;../Core/Code/Interface;../Core/Code/Alientek;../Core/Code/Module;../Core/Code/Tool;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_spi.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Code
    ../Core/Code/Main/: code.c test.c
    ../Core/Code/Interface/: my_gpio.c my_usart.c my_i2c.c my_spi.c
    ../Core/Code/Module/: my_qmc5883.c my_w25q64.c
    ../Core/Code/Tool/: multi_printf.c
  group Alientek
    ../Core/Code/Alientek/: atk_delay.c atk_sys.c atk_usart.c atk_usmart.c atk_usmart_config.c atk_usmart_str.c atk_malloc.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 4.3.0
