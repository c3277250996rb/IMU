# Keil uVision project stm32f103rct6.uvprojx, settings and files
target stm32f103rct6 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103rct6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Core/Code/Interface;../Core/Code/Main;../Core/Code/Tool;../Core/Code/Module;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Code/System/fatfs;../Core/Code/Alientek
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Code
    ../Core/Code/Interface/: my_gpio.c my_i2c.c my_usart.c my_spi.c bsp_spi_flash.c
    ../Core/Code/Main/: code.c test.c
    ../Core/Code/Module/: my_lsm6ds3.c my_mpu9250.c my_qmc5883.c my_led.c my_w25q64.c
    ../Core/Code/Tool/: init_check.c quaternion.c convert_string.c data_management.c multi_printf.c windows_filter.c scene_judgement.c trend_extremum.c my_array.c
  group System
    ../Core/Code/System/fatfs/: my_fatfs.c diskio.c ff.c ffsystem.c ffunicode.c cc936.c
  group Alientek
    ../Core/Code/Alientek/: atk_delay.c atk_sys.c atk_usart.c atk_usmart.c atk_usmart_config.c atk_usmart_str.c atk_malloc.c
software components: CMSIS:CORE 4.3.0
