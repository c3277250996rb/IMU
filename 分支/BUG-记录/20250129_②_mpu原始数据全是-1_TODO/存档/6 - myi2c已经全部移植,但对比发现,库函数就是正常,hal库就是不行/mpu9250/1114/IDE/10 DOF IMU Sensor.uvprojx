# Keil uVision project 10 DOF IMU Sensor.uvprojx, settings and files
target 10 DOF IMU Sensor (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mpu_9axes +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SRC\CMSIS\CoreSupport;..\SRC\CMSIS\DeviceSupport;..\SRC\HardWare\LED;..\SRC\HardWare\USART;..\SRC\HardWare\MPU6050;..\SRC\HardWare\HMC5883L;..\SRC\HardWare\BMP180;..\SRC\HardWare\BMP280;..\SRC\Public;..\SRC\STM32F10x_StdPeriph_Driver\inc;..\SRC\System;..\SRC\User;..\SRC\HardWare\I2C;..\SRC\HardWare\IMU;..\SRC\HardWare\MPU9250;..\SRC\HardWare\invMotionSensor;..\SRC\HardWare\ICM20948
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../SRC/CMSIS/CoreSupport/: core_cm3.c
    ../SRC/CMSIS/DeviceSupport/: startup_stm32f10x_hd.s
  group HardWare
    ../SRC/HardWare/LED/: LED.c
    ../SRC/HardWare/USART/: USART.c
    ../SRC/HardWare/I2C/: I2C.c my_i2c.c my_mpu9250.c
    ../SRC/HardWare/IMU/: IMU.c
    ../SRC/HardWare/MPU9250/: MPU9250.c
    ../SRC/HardWare/BMP280/: BMP280.c
  group Public
    ../SRC/Public/: Public_StdMacros.h Public_StdTypes.h
  group STM32F10x_StdPeriph_Driver
    ../SRC/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c
  group System
    ../SRC/HardWare/invMotionSensor/: invMotionSensor.c
    ../SRC/System/: System.c
  group User
    ../SRC/User/: main.c stm32f10x_it.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
