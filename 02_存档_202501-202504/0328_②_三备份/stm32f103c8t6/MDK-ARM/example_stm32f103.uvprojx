# Keil uVision project example_stm32f103.uvprojx, settings and files
target example_stm32f103 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: example_stm32f103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Code/Interface;../Core/Code/Main;../Core/Code/Module;../Core/Code/System/fatfs;../Core/Code/Tool;..\Core\Code\Alientek
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Code
    ../Core/Code/Main/: code.c test.c
    ../Core/Code/Tool/: init_check.c quaternion.c multi_printf.c convert_string.c data_management.c
    ../Core/Code/Interface/: my_gpio.c my_i2c.c my_usart.c my_spi.c
    ../Core/Code/Module/: my_led.c my_lsm6ds3.c my_mpu9250.c my_qmc5883.c my_w25q64.c
  group System
    ../../stm32f103rct6/Core/Code/System/fatfs/: diskio.c ff.c my_fatfs.c
  group Alientek
    ../Core/Code/Alientek/: atk_delay.c atk_malloc.c atk_sys.c atk_usart.c atk_usmart.c atk_usmart_config.c atk_usmart_str.c my_alientek.c
software components: CMSIS:CORE 4.3.0
